# Keil uVision project FlatSatACS.uvprojx, settings and files
target FlatSatACS (6110000::V6.11::.\ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FlatSatACS +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\..\..\Mech_Lib;..\..\..\..\CommandControl\Spi_FRAM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Mech Lib
    ../../../Mech_Lib/: ACS.c ACS.h ACSStateMachine.c ACSStateMachine.h AttitudeEstimation.c AttitudeEstimation.h FeedbackControl.c FeedbackControl.h InertialVectors.c InertialVectors.h Matrix.c Matrix.h OrientationController.c PacketProtocol.c PacketProtocol.h ReferenceFrames.c ReferenceFrames.h StabilizationController.c STM32SerialCommunication.c STM32SerialCommunication.h
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group IGRF
    ../../../Mech_Lib/IGRF/: IGRF12.h mag_inertial.c mag_inertial.h
  group C&C Lib
    ../../../../CommandControl/Spi_FRAM/: SPI_FRAM.c SPI_FRAM.h
software components: CMSIS:CORE 5.1.2
